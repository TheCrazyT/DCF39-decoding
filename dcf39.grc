options:
  parameters:
    author: crazy
    generate_options: qt_gui
    id: dcf39
    output_language: python
    run: running
    title: Not titled yet
  states: {}

blocks:
- name: reduce
  id: variable
  parameters:
    value: samp_rate//200
  states: {}
- name: running
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '48'
    quad_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '48'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: p:\GnuRadio\out.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: p:\GnuRadio\valid_bytes.bin
    type: byte
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: p:\GnuRadio\out_binary.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: example.complex
    repeat: 'False'
    type: float
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '1000'
    sample_rate: samp_rate
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: reduce
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '450'
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: reduce
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '48'
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '2'
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-0.01'
    init: '0'
    low: '0.01'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def _dbg(self,s):
              print(s)
              
          def _nulldbg(self,s):
              pass

          def __init__(self,debug=False):  # only default arguments here
              gr.basic_block.__init__(
                  self,
                  name='Filter valid bytes',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              self.code = 0
              self.startCodeFound = False
              self.output = []
              if debug:
                  self.dbg = self._dbg
              else:
                  self.dbg = self._nulldbg
          
          def reverse_bits(self, code):
              return (
                     (((code & (1<<7)) >> 7) << 0) |
                     (((code & (1<<6)) >> 6) << 1) |
                     (((code & (1<<5)) >> 5) << 2) |
                     (((code & (1<<4)) >> 4) << 3) |
                     (((code & (1<<3)) >> 3) << 4) |
                     (((code & (1<<2)) >> 2) << 5) |
                     (((code & (1<<1)) >> 1) << 6) |
                     (((code & (1<<0)) >> 0) << 7)
                     )
          
          def get_byte(self, code):
              return self.reverse_bits((code >> 2) & 0xFF)
          
          def get_bit_stream(self, code):
              v = code
              r = ""
              for i in range(10,-1,-1):
                  if (((1 << i) & code) >> i) == 1:
                      s = "1"
                  else:
                      s = "0"
                  r += s
              return r
          
          def calc_parity(self, code):
              return (
                      ((code & (1 << 2)) >> 2) ^
                      ((code & (1 << 3)) >> 3) ^
                      ((code & (1 << 4)) >> 4) ^
                      ((code & (1 << 5)) >> 5) ^
                      ((code & (1 << 6)) >> 6) ^
                      ((code & (1 << 7)) >> 7) ^
                      ((code & (1 << 8)) >> 8) ^
                      ((code & (1 << 9)) >> 9)
                     )

          def handle_bit(self, b):
              self.code <<= 1
              self.code |= b
              self.code &= 0x7FF
              p = self.calc_parity(self.code)
              if (
                  ((self.code & 1) == 1)                 #stopbit
                  and 
                  ((self.code & (1 << 1)) == (p << 1))   #parityBit
                  and 
                  ((self.code & (1 << 10)) == (0 << 10))   #startbit
                 ):
                  bt = self.get_byte(self.code)
                  if not self.startCodeFound:
                      if bt == 0x68:
                          self.startCodeFound = True
                  if self.startCodeFound:
                      self.output.append(bt)
                      bs = self.get_bit_stream(self.code)
                      self.dbg("%04d %02x %s" % (self.code,bt,bs))
                      self.code = 0x7FF
                  else:
                      bs = self.get_bit_stream(self.code)

          
          def general_work(self, input_items, output_items):
              out = output_items[0]
              inp = input_items[0][:len(out)]
              self.output = []
              for i in range(0,len(out)):
                  self.handle_bit(inp[i])
              self.consume(0, len(inp))
              ln = len(self.output)
              if ln>0:
                  out[:ln] = self.output
                  #self.dbg(ln)
              return ln
    debug: 'False'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """
      import pmt
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              gr.basic_block.__init__(
                  self,
                  name='Tag valid bytes',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.code = 0
              self.startCodeFound = False
              self.lastCode = 0
              self.lastOutput = None
          
          def get_bit_stream(self, code):
              v = code
              r = ""
              for i in range(9,-1,-1):
                  if (((1 << i) & code) >> i) == 1:
                      s = "1"
                  else:
                      s = "0"
                  r += s
              return r
          
          def reverse_bits(self, code):
              return (
                     (((code & (1<<7)) >> 7) << 0) |
                     (((code & (1<<6)) >> 6) << 1) |
                     (((code & (1<<5)) >> 5) << 2) |
                     (((code & (1<<4)) >> 4) << 3) |
                     (((code & (1<<3)) >> 3) << 4) |
                     (((code & (1<<2)) >> 2) << 5) |
                     (((code & (1<<1)) >> 1) << 6) |
                     (((code & (1<<0)) >> 0) << 7)
                     )
          
          def get_byte(self, code):
              return self.reverse_bits((code >> 2) & 0xFF)
          
          def calc_parity(self, code):
              return (
                      ((code & (1 << 2)) >> 2) ^
                      ((code & (1 << 3)) >> 3) ^
                      ((code & (1 << 4)) >> 4) ^
                      ((code & (1 << 5)) >> 5) ^
                      ((code & (1 << 6)) >> 6) ^
                      ((code & (1 << 7)) >> 7) ^
                      ((code & (1 << 8)) >> 8) ^
                      ((code & (1 << 9)) >> 9)
                     )
              
          def handle_bit(self, b):
              self.code <<= 1
              self.code |= b
              self.code &= 0x7FF
              p = self.calc_parity(self.code)
              if (
                  ((self.code & 1) == 1)                 #stopbit
                  and 
                  ((self.code & (1 << 1)) == (p << 1))   #parityBit
                  and
                  ((self.code & (1 << 10)) == (0 << 10))   #startbit
                 ):
                  bt = self.get_byte(self.code)
                  self.lastOutput = bt
                  self.lastCode = self.code
                  self.code = 0x7FF

          
          def general_work(self, input_items, output_items):
              out = output_items[0]
              inp = input_items[0][:len(out)]
              for i in range(0,len(out)):
                  self.lastOutput = None
                  self.lastCode   = 0
                  self.handle_bit((inp[i] > 0)*1)
                  if self.lastOutput is not None:
                      self.add_item_tag(0,self.nitems_written(0) + i,pmt.intern("byte"),pmt.string_to_symbol("%02x" % self.lastOutput))
                      self.add_item_tag(0,self.nitems_written(0) + i,pmt.intern("lastCode"),pmt.string_to_symbol(self.get_bit_stream(self.lastCode)))
              self.consume(0, len(inp))
              ln = len(inp)
              out[:ln] = inp
              return ln
  states: {}
- name: gr_digital_rf_raster_tag_0
  id: gr_digital_rf_raster_tag
  parameters:
    input: f32
    max_raster_length: '0'
    raster_length: reduce
    tags: '[(0, "R", "")]'
    vlen: '1'
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Demodulated signal
    label2: Threshold detection
    label3: Decimized threshold-detection signal
    name: '"Decoding graph"'
    nconnections: '3'
    size: 10240*4
    srate: samp_rate
    type: float
    update_time: '0.010'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_repeat_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_file_sink_0_1, '0']
- [blocks_file_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_char_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_float_to_char_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_char_0, '0', epy_block_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_freqshift_cc_0, '0', analog_wfm_rcv_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_keep_one_in_n_0, '0', epy_block_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repeat_0, '0', gr_digital_rf_raster_tag_0, '0']
- [blocks_repeat_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_threshold_ff_0, '0', virtual_sink_0, '0']
- [epy_block_0_0, '0', blocks_file_sink_0_0, '0']
- [epy_block_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [epy_block_0_0_0, '0', blocks_repeat_0, '0']
- [gr_digital_rf_raster_tag_0, '0', qtgui_time_sink_x_1, '2']
- [pdu_tagged_stream_to_pdu_0_0, pdus, satellites_hexdump_sink_0, in]
- [virtual_source_0, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_0_0, '0', blocks_threshold_ff_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
